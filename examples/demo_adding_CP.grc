<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>variable_struct_0</value></param>
<param><key>value0</key><value>0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/habbo/Escritorio/prueba</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>2**(10+mode)</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate/4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1248</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1248</value></param>
<param><key>vector</key><value>[0]*1248</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>2304</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>2048</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(2048)</value></param>
</block>
<block>
<key>isdbt_agregar_cp</key>
<param><key>id</key><value>isdbt_agregar_cp_0</value></param>
<param><key>cp_length</key><value>0.125</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>isdbt_ofdm_frame_structure</key>
<param><key>id</key><value>isdbt_ofdm_frame_structure_0</value></param>
<param><key>ConvCodeA</key><value>0</value></param>
<param><key>ConvCodeB</key><value>6</value></param>
<param><key>ConvCodeC</key><value>6</value></param>
<param><key>IntLenA</key><value>0</value></param>
<param><key>IntLenB</key><value>0</value></param>
<param><key>IntLenC</key><value>0</value></param>
<param><key>ModeA</key><value>2</value></param>
<param><key>LayASeg</key><value>1</value></param>
<param><key>ModeB</key><value>4</value></param>
<param><key>LayBSeg</key><value>0</value></param>
<param><key>ModeC</key><value>4</value></param>
<param><key>LayCSeg</key><value>0</value></param>
<param><key>IsOneSeg</key><value>False</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>2304</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.03125</value></param>
<param><key>ymax</key><value>(2**(10+mode))</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>isdbt_ofdm_frame_structure_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>isdbt_agregar_cp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_agregar_cp_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_frame_structure_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_frame_structure_0</source_block_id><sink_block_id>blocks_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_frame_structure_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
