<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>96</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>range(96)</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>96</value></param>
</block>
<block>
<key>isdbt_frec_interleaver</key>
<param><key>id</key><value>isdbt_frec_interleaver_0</value></param>
<param><key>IsFullSeg</key><value>False</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>isdbt_frequency_deinterleaver_1seg</key>
<param><key>id</key><value>isdbt_frequency_deinterleaver_1seg_0</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>isdbt_time_deinterleaver_1seg</key>
<param><key>id</key><value>isdbt_time_deinterleaver_1seg_0</value></param>
<param><key>length</key><value>96</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>isdbt_time_interleaver</key>
<param><key>id</key><value>isdbt_time_interleaver_0</value></param>
<param><key>IsFullSeg</key><value>False</value></param>
<param><key>I</key><value>0</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>isdbt_frec_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_frec_interleaver_0</source_block_id><sink_block_id>isdbt_time_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_frequency_deinterleaver_1seg_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_time_deinterleaver_1seg_0</source_block_id><sink_block_id>isdbt_frequency_deinterleaver_1seg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_time_interleaver_0</source_block_id><sink_block_id>isdbt_time_deinterleaver_1seg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
