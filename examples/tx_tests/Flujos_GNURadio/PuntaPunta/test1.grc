<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>551e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mode</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/habbo/Documents/PruebasISDBT/Salidas/Layer_A.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>188</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/habbo/Documents/PruebasISDBT/Salidas/Layer_B.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>188</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>/home/habbo/Documents/PruebasISDBT/Salidas/fs__RSin_layA.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0</value></param>
<param><key>file</key><value>/home/habbo/Documents/PruebasISDBT/Salidas/fs__RSin_layB.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_0</value></param>
<param><key>file</key><value>/home/habbo/Documents/PruebasISDBT/Salidas/fs__VDin_layB.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_1</value></param>
<param><key>file</key><value>/home/habbo/Documents/PruebasISDBT/Salidas/fs__RSin_layC.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_1_0</value></param>
<param><key>file</key><value>/home/habbo/Documents/PruebasISDBT/Salidas/fs__VDin_layC.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_2</value></param>
<param><key>file</key><value>/home/habbo/Documents/PruebasISDBT/Salidas/fs__VDin_layA.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1</value></param>
<param><key>file</key><value>/home/habbo/Documents/PruebasISDBT/Salidas/Layer_C.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>188</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/habbo/Documents/PruebasISDBT/Salidas/Frecuencia_recepcion.ts</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>192*13</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/habbo/Documents/PruebasISDBT/Salidas/Frecuencia_transmisor.ts</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>192*13</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/habbo/Documents/BTS_Validos/BTS_ISDB_T_3_CAPAS.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>204*2304</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.01</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>6</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0_0</value></param>
<param><key>bits_per_chunk</key><value>6</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0_0_0</value></param>
<param><key>bits_per_chunk</key><value>6</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>192*1</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>192*6</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>192*6</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>filter</key><value>"frame_begin"</value></param>
<param><key>name</key><value>LayA</value></param>
<param><key>vlen</key><value>204</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>512/63e-6</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>6</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0_0</value></param>
<param><key>bits_per_chunk</key><value>6</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0_1</value></param>
<param><key>bits_per_chunk</key><value>6</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>4096</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_1_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>126</value></param>
<param><key>vlen</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>756</value></param>
<param><key>vlen</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>756</value></param>
<param><key>vlen</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1_0_1_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1_0_1_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1_2_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>216*13+1</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1_2_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>192*13</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>512</value></param>
<param><key>input_size</key><value>4096</value></param>
<param><key>tagname</key><value>""</value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0</value></param>
<param><key>code_rate</key><value>C1_2</value></param>
<param><key>constellation</key><value>64qam</value></param>
<param><key>hierarchy</key><value>alpha2</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512</value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0_0</value></param>
<param><key>code_rate</key><value>C1_2</value></param>
<param><key>constellation</key><value>64qam</value></param>
<param><key>hierarchy</key><value>alpha2</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512</value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0_0_0</value></param>
<param><key>code_rate</key><value>C1_2</value></param>
<param><key>constellation</key><value>64qam</value></param>
<param><key>hierarchy</key><value>alpha2</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0</value></param>
<param><key>blocks</key><value>1</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0_0</value></param>
<param><key>blocks</key><value>1</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0_0_0</value></param>
<param><key>blocks</key><value>1</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>label</key><value>fft_size</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fft_size)</value></param>
</block>
<block>
<key>isdbt_bit_deinterleaver</key>
<param><key>id</key><value>isdbt_bit_deinterleaver_0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>segments</key><value>1</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_bit_deinterleaver</key>
<param><key>id</key><value>isdbt_bit_deinterleaver_0_0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>segments</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_bit_deinterleaver</key>
<param><key>id</key><value>isdbt_bit_deinterleaver_0_1</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>segments</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_byte_deinterleaver</key>
<param><key>id</key><value>isdbt_byte_deinterleaver_0</value></param>
</block>
<block>
<key>isdbt_byte_deinterleaver</key>
<param><key>id</key><value>isdbt_byte_deinterleaver_0_0</value></param>
</block>
<block>
<key>isdbt_byte_deinterleaver</key>
<param><key>id</key><value>isdbt_byte_deinterleaver_0_1</value></param>
</block>
<block>
<key>isdbt_byte_interleaver</key>
<param><key>id</key><value>isdbt_byte_interleaver_0</value></param>
<param><key>conv_code</key><value>0</value></param>
<param><key>segments</key><value>1</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_byte_interleaver</key>
<param><key>id</key><value>isdbt_byte_interleaver_0_0</value></param>
<param><key>conv_code</key><value>0</value></param>
<param><key>segments</key><value>6</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_byte_interleaver</key>
<param><key>id</key><value>isdbt_byte_interleaver_0_0_0</value></param>
<param><key>conv_code</key><value>0</value></param>
<param><key>segments</key><value>6</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_energy_descrambler</key>
<param><key>id</key><value>isdbt_energy_descrambler_0</value></param>
</block>
<block>
<key>isdbt_energy_descrambler</key>
<param><key>id</key><value>isdbt_energy_descrambler_0_0</value></param>
</block>
<block>
<key>isdbt_energy_descrambler</key>
<param><key>id</key><value>isdbt_energy_descrambler_0_1</value></param>
</block>
<block>
<key>isdbt_energy_dispersal</key>
<param><key>id</key><value>isdbt_energy_dispersal_0</value></param>
</block>
<block>
<key>isdbt_energy_dispersal</key>
<param><key>id</key><value>isdbt_energy_dispersal_0_0</value></param>
</block>
<block>
<key>isdbt_energy_dispersal</key>
<param><key>id</key><value>isdbt_energy_dispersal_0_0_0</value></param>
</block>
<block>
<key>isdbt_frec_interleaver</key>
<param><key>id</key><value>isdbt_frec_interleaver_0</value></param>
<param><key>IsFullSeg</key><value>True</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_frequency_deinterleaver</key>
<param><key>id</key><value>isdbt_frequency_deinterleaver_0</value></param>
<param><key>oneseg</key><value>False</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_hierarchical_combination</key>
<param><key>id</key><value>isdbt_hierarchical_combination_0</value></param>
<param><key>segments_a</key><value>1</value></param>
<param><key>segments_b</key><value>6</value></param>
<param><key>segments_c</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_hierarchical_divisor</key>
<param><key>id</key><value>isdbt_hierarchical_divisor_0</value></param>
</block>
<block>
<key>isdbt_mapper</key>
<param><key>id</key><value>isdbt_mapper_0</value></param>
<param><key>segments</key><value>1</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_mapper</key>
<param><key>id</key><value>isdbt_mapper_0_0</value></param>
<param><key>segments</key><value>6</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_mapper</key>
<param><key>id</key><value>isdbt_mapper_0_0_0</value></param>
<param><key>segments</key><value>6</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_ofdm_frame_structure</key>
<param><key>id</key><value>isdbt_ofdm_frame_structure_0</value></param>
<param><key>ConvCodeA</key><value>0</value></param>
<param><key>ConvCodeB</key><value>0</value></param>
<param><key>ConvCodeC</key><value>0</value></param>
<param><key>IsFullSeg</key><value>True</value></param>
<param><key>IntLenA</key><value>8</value></param>
<param><key>IntLenB</key><value>8</value></param>
<param><key>IntLenC</key><value>8</value></param>
<param><key>ModeA</key><value>3</value></param>
<param><key>LayASeg</key><value>1</value></param>
<param><key>ModeB</key><value>3</value></param>
<param><key>LayBSeg</key><value>6</value></param>
<param><key>ModeC</key><value>3</value></param>
<param><key>LayCSeg</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_ofdm_synchronization</key>
<param><key>id</key><value>isdbt_ofdm_synchronization_0</value></param>
<param><key>cp_length</key><value>0.125</value></param>
<param><key>interpolate</key><value>False</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_reed_solomon_dec_isdbt</key>
<param><key>id</key><value>isdbt_reed_solomon_dec_isdbt_0</value></param>
</block>
<block>
<key>isdbt_reed_solomon_dec_isdbt</key>
<param><key>id</key><value>isdbt_reed_solomon_dec_isdbt_0_0</value></param>
</block>
<block>
<key>isdbt_reed_solomon_dec_isdbt</key>
<param><key>id</key><value>isdbt_reed_solomon_dec_isdbt_0_1</value></param>
</block>
<block>
<key>isdbt_symbol_demapper</key>
<param><key>id</key><value>isdbt_symbol_demapper_0</value></param>
<param><key>constellation_size_A</key><value>64</value></param>
<param><key>segments_A</key><value>1</value></param>
<param><key>constellation_size_B</key><value>64</value></param>
<param><key>segments_B</key><value>6</value></param>
<param><key>constellation_size_C</key><value>64</value></param>
<param><key>segments_C</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_time_deinterleaver</key>
<param><key>id</key><value>isdbt_time_deinterleaver_0</value></param>
<param><key>length_A</key><value>8</value></param>
<param><key>segments_A</key><value>1</value></param>
<param><key>length_B</key><value>8</value></param>
<param><key>segments_B</key><value>6</value></param>
<param><key>length_C</key><value>8</value></param>
<param><key>segments_C</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_time_interleaver</key>
<param><key>id</key><value>isdbt_time_interleaver_0</value></param>
<param><key>IsFullSeg</key><value>True</value></param>
<param><key>I</key><value>8</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_tmcc_decoder</key>
<param><key>id</key><value>isdbt_tmcc_decoder_0</value></param>
<param><key>print_params</key><value>False</value></param>
<param><key>transmission_mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_tsp_resize</key>
<param><key>id</key><value>isdbt_tsp_resize_0</value></param>
</block>
<block>
<key>isdbt_tsp_resize</key>
<param><key>id</key><value>isdbt_tsp_resize_0_0</value></param>
</block>
<block>
<key>isdbt_tsp_resize</key>
<param><key>id</key><value>isdbt_tsp_resize_0_0_0</value></param>
</block>
<block>
<key>isdbt_viterbi_decoder</key>
<param><key>id</key><value>isdbt_viterbi_decoder_0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>rate</key><value>0</value></param>
</block>
<block>
<key>isdbt_viterbi_decoder</key>
<param><key>id</key><value>isdbt_viterbi_decoder_0_0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>rate</key><value>0</value></param>
</block>
<block>
<key>isdbt_viterbi_decoder</key>
<param><key>id</key><value>isdbt_viterbi_decoder_0_1</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>rate</key><value>0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"OFDM Out"</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1_0_0_0_1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Time Denint OUT"</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>isdbt_hierarchical_divisor_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>isdbt_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0_0</source_block_id><sink_block_id>isdbt_mapper_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0_0_0</source_block_id><sink_block_id>isdbt_mapper_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>isdbt_hierarchical_combination_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>isdbt_hierarchical_combination_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>isdbt_hierarchical_combination_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>isdbt_ofdm_synchronization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>isdbt_viterbi_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_0</source_block_id><sink_block_id>isdbt_viterbi_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_1</source_block_id><sink_block_id>isdbt_viterbi_decoder_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0_0_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_1</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_1_0</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>isdbt_tsp_resize_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_0</source_block_id><sink_block_id>isdbt_tsp_resize_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_0_0</source_block_id><sink_block_id>isdbt_tsp_resize_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_0_1_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_0_1_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1_2_0_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1_2_0_0_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0</source_block_id><sink_block_id>isdbt_energy_dispersal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0_0</source_block_id><sink_block_id>isdbt_energy_dispersal_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0_0_0</source_block_id><sink_block_id>isdbt_energy_dispersal_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_bit_deinterleaver_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_bit_deinterleaver_0_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_bit_deinterleaver_0_1</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_deinterleaver_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_deinterleaver_0</source_block_id><sink_block_id>isdbt_energy_descrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_deinterleaver_0_0</source_block_id><sink_block_id>isdbt_energy_descrambler_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_deinterleaver_0_1</source_block_id><sink_block_id>isdbt_energy_descrambler_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_interleaver_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_interleaver_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_interleaver_0_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0</source_block_id><sink_block_id>isdbt_reed_solomon_dec_isdbt_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0_0</source_block_id><sink_block_id>isdbt_reed_solomon_dec_isdbt_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0_1</source_block_id><sink_block_id>blocks_vector_to_stream_0_1_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0_1</source_block_id><sink_block_id>isdbt_reed_solomon_dec_isdbt_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_dispersal_0</source_block_id><sink_block_id>isdbt_byte_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_dispersal_0_0</source_block_id><sink_block_id>isdbt_byte_interleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_dispersal_0_0_0</source_block_id><sink_block_id>isdbt_byte_interleaver_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_frec_interleaver_0</source_block_id><sink_block_id>blocks_file_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_frec_interleaver_0</source_block_id><sink_block_id>isdbt_ofdm_frame_structure_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_frequency_deinterleaver_0</source_block_id><sink_block_id>isdbt_time_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_combination_0</source_block_id><sink_block_id>isdbt_time_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_divisor_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_divisor_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_divisor_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_mapper_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_mapper_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_mapper_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_frame_structure_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_synchronization_0</source_block_id><sink_block_id>blocks_vector_to_stream_1_2_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_synchronization_0</source_block_id><sink_block_id>isdbt_tmcc_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_reed_solomon_dec_isdbt_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_reed_solomon_dec_isdbt_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_reed_solomon_dec_isdbt_0_1</source_block_id><sink_block_id>blocks_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_bit_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_bit_deinterleaver_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_bit_deinterleaver_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_time_deinterleaver_0</source_block_id><sink_block_id>blocks_vector_to_stream_1_2_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_time_deinterleaver_0</source_block_id><sink_block_id>isdbt_symbol_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_time_interleaver_0</source_block_id><sink_block_id>isdbt_frec_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tmcc_decoder_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tmcc_decoder_0</source_block_id><sink_block_id>isdbt_frequency_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tsp_resize_0</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tsp_resize_0_0</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tsp_resize_0_0_0</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_viterbi_decoder_0</source_block_id><sink_block_id>isdbt_byte_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_viterbi_decoder_0_0</source_block_id><sink_block_id>isdbt_byte_deinterleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_viterbi_decoder_0_1</source_block_id><sink_block_id>isdbt_byte_deinterleaver_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
