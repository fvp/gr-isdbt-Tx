<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0</value></param>
<param><key>file</key><value>/home/habbo/Documents/PruebasISDBT/Salidas/Envio_test_5.ts</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0</value></param>
<param><key>file</key><value>/home/habbo/Documents/BTS_Validos/BTS_ISDB_T_3_CAPAS.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>204*2176</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>204*712</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>712*204</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>6</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>119</value></param>
<param><key>vlen</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>204</value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0</value></param>
<param><key>code_rate</key><value>C1_2</value></param>
<param><key>constellation</key><value>64qam</value></param>
<param><key>hierarchy</key><value>nh</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0</value></param>
<param><key>blocks</key><value>1</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>isdbt_byte_interleaver</key>
<param><key>id</key><value>isdbt_byte_interleaver_0</value></param>
<param><key>conv_code</key><value>0</value></param>
<param><key>segments</key><value>1</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_energy_dispersal</key>
<param><key>id</key><value>isdbt_energy_dispersal_1</value></param>
</block>
<block>
<key>isdbt_hierarchical_divisor</key>
<param><key>id</key><value>isdbt_hierarchical_divisor_0</value></param>
</block>
<block>
<key>isdbt_mapper</key>
<param><key>id</key><value>isdbt_mapper_0</value></param>
<param><key>constellation</key><value>3</value></param>
<param><key>IsFullSeg</key><value>False</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_tsp_resize</key>
<param><key>id</key><value>isdbt_tsp_resize_0_2</value></param>
</block>
<connection><source_block_id>blocks_file_source_0_0_0</source_block_id><sink_block_id>isdbt_hierarchical_divisor_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>isdbt_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>isdbt_tsp_resize_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0</source_block_id><sink_block_id>isdbt_energy_dispersal_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_interleaver_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_dispersal_1</source_block_id><sink_block_id>isdbt_byte_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_divisor_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_divisor_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_divisor_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_mapper_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tsp_resize_0_2</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
