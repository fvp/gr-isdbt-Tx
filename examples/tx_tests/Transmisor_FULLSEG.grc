<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/santiago/Escritorio/CAPA_A.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/santiago/Escritorio/CAPA_B.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/santiago/Escritorio/CAPA_C.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0</value></param>
<param><key>file</key><value>/home/santiago/Escritorio/BTS_ISDB_T_3_CAPAS.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>204*2304</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>192</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>192*6</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>192*6</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"frame_begin"</value></param>
<param><key>packet_len</key><value>72</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>204</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"frame_begin"</value></param>
<param><key>packet_len</key><value>432</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>204</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"frame_begin"</value></param>
<param><key>packet_len</key><value>72*6</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>204</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>192</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>192*6</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>192*6</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>188</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>126</value></param>
<param><key>vlen</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>756</value></param>
<param><key>vlen</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>756</value></param>
<param><key>vlen</key><value>204</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>188</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>188</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>512</value></param>
<param><key>input_size</key><value>4096</value></param>
<param><key>tagname</key><value>""</value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0</value></param>
<param><key>code_rate</key><value>C1_2</value></param>
<param><key>constellation</key><value>64qam</value></param>
<param><key>hierarchy</key><value>alpha2</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512</value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0_0</value></param>
<param><key>code_rate</key><value>C1_2</value></param>
<param><key>constellation</key><value>64qam</value></param>
<param><key>hierarchy</key><value>alpha2</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512</value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0_1</value></param>
<param><key>code_rate</key><value>C1_2</value></param>
<param><key>constellation</key><value>64qam</value></param>
<param><key>hierarchy</key><value>alpha2</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0_0</value></param>
<param><key>blocks</key><value>1</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0_0_0</value></param>
<param><key>blocks</key><value>1</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0_0_1</value></param>
<param><key>blocks</key><value>1</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>4096</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(4096)</value></param>
</block>
<block>
<key>isdbt_bit_deinterleaver</key>
<param><key>id</key><value>isdbt_bit_deinterleaver_0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>segments</key><value>1</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_bit_deinterleaver</key>
<param><key>id</key><value>isdbt_bit_deinterleaver_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>segments</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_bit_deinterleaver</key>
<param><key>id</key><value>isdbt_bit_deinterleaver_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>segments</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_byte_deinterleaver</key>
<param><key>id</key><value>isdbt_byte_deinterleaver_0</value></param>
</block>
<block>
<key>isdbt_byte_deinterleaver</key>
<param><key>id</key><value>isdbt_byte_deinterleaver_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_byte_deinterleaver</key>
<param><key>id</key><value>isdbt_byte_deinterleaver_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_byte_interleaver</key>
<param><key>id</key><value>isdbt_byte_interleaver_0</value></param>
<param><key>conv_code</key><value>0</value></param>
<param><key>segments</key><value>1</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_byte_interleaver</key>
<param><key>id</key><value>isdbt_byte_interleaver_0_0</value></param>
<param><key>conv_code</key><value>0</value></param>
<param><key>segments</key><value>6</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_byte_interleaver</key>
<param><key>id</key><value>isdbt_byte_interleaver_0_1</value></param>
<param><key>conv_code</key><value>0</value></param>
<param><key>segments</key><value>6</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_energy_descrambler</key>
<param><key>id</key><value>isdbt_energy_descrambler_0</value></param>
</block>
<block>
<key>isdbt_energy_descrambler</key>
<param><key>id</key><value>isdbt_energy_descrambler_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_energy_descrambler</key>
<param><key>id</key><value>isdbt_energy_descrambler_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_energy_dispersal</key>
<param><key>id</key><value>isdbt_energy_dispersal_0</value></param>
<param><key>tsp_per_frame</key><value>72</value></param>
</block>
<block>
<key>isdbt_energy_dispersal</key>
<param><key>id</key><value>isdbt_energy_dispersal_0_0</value></param>
<param><key>tsp_per_frame</key><value>432</value></param>
</block>
<block>
<key>isdbt_energy_dispersal</key>
<param><key>id</key><value>isdbt_energy_dispersal_0_1</value></param>
<param><key>tsp_per_frame</key><value>72*6</value></param>
</block>
<block>
<key>isdbt_frec_interleaver</key>
<param><key>id</key><value>isdbt_frec_interleaver_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>IsFullSeg</key><value>True</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_frequency_deinterleaver</key>
<param><key>id</key><value>isdbt_frequency_deinterleaver_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>oneseg</key><value>True</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_hierarchical_combination</key>
<param><key>id</key><value>isdbt_hierarchical_combination_0</value></param>
<param><key>segments_a</key><value>1</value></param>
<param><key>segments_b</key><value>6</value></param>
<param><key>segments_c</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_hierarchical_divisor</key>
<param><key>id</key><value>isdbt_hierarchical_divisor_0</value></param>
</block>
<block>
<key>isdbt_mapper</key>
<param><key>id</key><value>isdbt_mapper_0</value></param>
<param><key>segments</key><value>1</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_mapper</key>
<param><key>id</key><value>isdbt_mapper_0_0</value></param>
<param><key>segments</key><value>6</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_mapper</key>
<param><key>id</key><value>isdbt_mapper_0_1</value></param>
<param><key>segments</key><value>6</value></param>
<param><key>mod_scheme</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_ofdm_frame_structure</key>
<param><key>id</key><value>isdbt_ofdm_frame_structure_0</value></param>
<param><key>ConvCodeA</key><value>0</value></param>
<param><key>ConvCodeB</key><value>0</value></param>
<param><key>ConvCodeC</key><value>0</value></param>
<param><key>IsFullSeg</key><value>True</value></param>
<param><key>IntLenA</key><value>8</value></param>
<param><key>IntLenB</key><value>8</value></param>
<param><key>IntLenC</key><value>8</value></param>
<param><key>ModeA</key><value>3</value></param>
<param><key>LayASeg</key><value>1</value></param>
<param><key>ModeB</key><value>3</value></param>
<param><key>LayBSeg</key><value>6</value></param>
<param><key>ModeC</key><value>3</value></param>
<param><key>LayCSeg</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_ofdm_synchronization</key>
<param><key>id</key><value>isdbt_ofdm_synchronization_0</value></param>
<param><key>cp_length</key><value>0.125</value></param>
<param><key>interpolate</key><value>True</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_reed_solomon_dec_isdbt</key>
<param><key>id</key><value>isdbt_reed_solomon_dec_isdbt_0</value></param>
</block>
<block>
<key>isdbt_reed_solomon_dec_isdbt</key>
<param><key>id</key><value>isdbt_reed_solomon_dec_isdbt_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_reed_solomon_dec_isdbt</key>
<param><key>id</key><value>isdbt_reed_solomon_dec_isdbt_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_symbol_demapper</key>
<param><key>id</key><value>isdbt_symbol_demapper_0</value></param>
<param><key>constellation_size_A</key><value>64</value></param>
<param><key>segments_A</key><value>1</value></param>
<param><key>constellation_size_B</key><value>64</value></param>
<param><key>segments_B</key><value>6</value></param>
<param><key>constellation_size_C</key><value>64</value></param>
<param><key>segments_C</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_sync_adjust</key>
<param><key>id</key><value>isdbt_sync_adjust_0</value></param>
</block>
<block>
<key>isdbt_sync_adjust</key>
<param><key>id</key><value>isdbt_sync_adjust_0_0</value></param>
</block>
<block>
<key>isdbt_sync_adjust</key>
<param><key>id</key><value>isdbt_sync_adjust_0_1</value></param>
</block>
<block>
<key>isdbt_time_deinterleaver</key>
<param><key>id</key><value>isdbt_time_deinterleaver_0</value></param>
<param><key>length_A</key><value>8</value></param>
<param><key>segments_A</key><value>1</value></param>
<param><key>length_B</key><value>8</value></param>
<param><key>segments_B</key><value>6</value></param>
<param><key>length_C</key><value>8</value></param>
<param><key>segments_C</key><value>6</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_time_interleaver</key>
<param><key>id</key><value>isdbt_time_interleaver_0</value></param>
<param><key>IsFullSeg</key><value>True</value></param>
<param><key>I</key><value>8</value></param>
<param><key>mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_tmcc_decoder</key>
<param><key>id</key><value>isdbt_tmcc_decoder_0</value></param>
<param><key>print_params</key><value>True</value></param>
<param><key>transmission_mode</key><value>2</value></param>
</block>
<block>
<key>isdbt_tsp_resize</key>
<param><key>id</key><value>isdbt_tsp_resize_0_2</value></param>
</block>
<block>
<key>isdbt_tsp_resize</key>
<param><key>id</key><value>isdbt_tsp_resize_0_2_0</value></param>
</block>
<block>
<key>isdbt_tsp_resize</key>
<param><key>id</key><value>isdbt_tsp_resize_0_2_1</value></param>
</block>
<block>
<key>isdbt_viterbi_decoder</key>
<param><key>id</key><value>isdbt_viterbi_decoder_0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>rate</key><value>0</value></param>
</block>
<block>
<key>isdbt_viterbi_decoder</key>
<param><key>id</key><value>isdbt_viterbi_decoder_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>rate</key><value>0</value></param>
</block>
<block>
<key>isdbt_viterbi_decoder</key>
<param><key>id</key><value>isdbt_viterbi_decoder_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>rate</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_file_source_0_0_0</source_block_id><sink_block_id>isdbt_hierarchical_divisor_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>isdbt_energy_descrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0_0</source_block_id><sink_block_id>isdbt_energy_descrambler_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0_0_0</source_block_id><sink_block_id>isdbt_energy_descrambler_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>isdbt_hierarchical_combination_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1_0</source_block_id><sink_block_id>isdbt_hierarchical_combination_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1_1</source_block_id><sink_block_id>isdbt_hierarchical_combination_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>isdbt_tsp_resize_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0_0</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0_1</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_1</source_block_id><sink_block_id>isdbt_tsp_resize_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_2</source_block_id><sink_block_id>isdbt_tsp_resize_0_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>isdbt_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_1</source_block_id><sink_block_id>isdbt_mapper_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_2</source_block_id><sink_block_id>isdbt_mapper_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>isdbt_ofdm_synchronization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0_1</source_block_id><sink_block_id>blocks_vector_to_stream_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0_0</source_block_id><sink_block_id>isdbt_sync_adjust_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0_0_0</source_block_id><sink_block_id>isdbt_sync_adjust_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0_0_1</source_block_id><sink_block_id>isdbt_sync_adjust_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_bit_deinterleaver_0</source_block_id><sink_block_id>isdbt_viterbi_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_bit_deinterleaver_0_0</source_block_id><sink_block_id>isdbt_viterbi_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_bit_deinterleaver_0_0_0</source_block_id><sink_block_id>isdbt_viterbi_decoder_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_deinterleaver_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_deinterleaver_0</source_block_id><sink_block_id>isdbt_energy_descrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_deinterleaver_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_deinterleaver_0_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_interleaver_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_interleaver_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_interleaver_0_1</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0</source_block_id><sink_block_id>isdbt_reed_solomon_dec_isdbt_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0_0</source_block_id><sink_block_id>isdbt_reed_solomon_dec_isdbt_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0_0_0</source_block_id><sink_block_id>isdbt_reed_solomon_dec_isdbt_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_dispersal_0</source_block_id><sink_block_id>isdbt_byte_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_dispersal_0_0</source_block_id><sink_block_id>isdbt_byte_interleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_dispersal_0_1</source_block_id><sink_block_id>isdbt_byte_interleaver_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_frec_interleaver_0</source_block_id><sink_block_id>isdbt_ofdm_frame_structure_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_frequency_deinterleaver_0</source_block_id><sink_block_id>isdbt_time_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_combination_0</source_block_id><sink_block_id>isdbt_time_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_divisor_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_divisor_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_divisor_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_mapper_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_mapper_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_mapper_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_frame_structure_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_synchronization_0</source_block_id><sink_block_id>isdbt_tmcc_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_reed_solomon_dec_isdbt_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_reed_solomon_dec_isdbt_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_reed_solomon_dec_isdbt_0_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_bit_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_bit_deinterleaver_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_bit_deinterleaver_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_sync_adjust_0</source_block_id><sink_block_id>isdbt_energy_dispersal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_sync_adjust_0_0</source_block_id><sink_block_id>isdbt_energy_dispersal_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_sync_adjust_0_1</source_block_id><sink_block_id>isdbt_energy_dispersal_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_time_deinterleaver_0</source_block_id><sink_block_id>isdbt_symbol_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_time_interleaver_0</source_block_id><sink_block_id>isdbt_frec_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tmcc_decoder_0</source_block_id><sink_block_id>isdbt_frequency_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tsp_resize_0_2</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tsp_resize_0_2_0</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tsp_resize_0_2_1</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_viterbi_decoder_0</source_block_id><sink_block_id>isdbt_byte_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_viterbi_decoder_0_0</source_block_id><sink_block_id>isdbt_byte_deinterleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_viterbi_decoder_0_0_0</source_block_id><sink_block_id>isdbt_byte_deinterleaver_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
