<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_demo_simple</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>active_carriers</value></param>
<param><key>value</key><value>13*108*2**(mode-1)+1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_carriers</value></param>
<param><key>value</key><value>13*96*2**(mode-1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>guard</value></param>
<param><key>value</key><value>1.0/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8e6*64/63</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>total_carriers</value></param>
<param><key>value</key><value>2**(10+mode)</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>test_out_layerB.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/habbo/Documents/Facultad/TestsBerretas/Flujos/out/layer_A.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>test_out_layerC.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1_0</value></param>
<param><key>file</key><value>/home/habbo/Documents/Facultad/TestsBerretas/Flujos/test_suite_0101.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_1</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>96*2**(mode-1)</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>96*2**(mode-1)*8</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>data_carriers</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>total_carriers</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(total_carriers)</value></param>
</block>
<block>
<key>isdbt_channel_decoding</key>
<param><key>id</key><value>isdbt_channel_decoding_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>layer_segments</key><value>8</value></param>
<param><key>constellation_size</key><value>16</value></param>
<param><key>rate</key><value>0</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>isdbt_channel_decoding</key>
<param><key>id</key><value>isdbt_channel_decoding_0_0</value></param>
<param><key>layer_segments</key><value>1</value></param>
<param><key>constellation_size</key><value>4</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>isdbt_channel_decoding</key>
<param><key>id</key><value>isdbt_channel_decoding_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>layer_segments</key><value>4</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>rate</key><value>1</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>isdbt_frequency_deinterleaver</key>
<param><key>id</key><value>isdbt_frequency_deinterleaver_0</value></param>
<param><key>oneseg</key><value>True</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>isdbt_ofdm_sym_acquisition</key>
<param><key>id</key><value>isdbt_ofdm_sym_acquisition_0</value></param>
<param><key>cp_length</key><value>int(guard*total_carriers)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_length</key><value>total_carriers</value></param>
<param><key>snr</key><value>10</value></param>
</block>
<block>
<key>isdbt_ofdm_synchronization</key>
<param><key>id</key><value>isdbt_ofdm_synchronization_0</value></param>
<param><key>cp_length</key><value>0.250</value></param>
<param><key>interpolate</key><value>True</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>isdbt_symbol_demapper</key>
<param><key>id</key><value>isdbt_symbol_demapper_0</value></param>
<param><key>constellation_size_A</key><value>4</value></param>
<param><key>segments_A</key><value>1</value></param>
<param><key>constellation_size_B</key><value>16</value></param>
<param><key>segments_B</key><value>8</value></param>
<param><key>constellation_size_C</key><value>64</value></param>
<param><key>segments_C</key><value>4</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>isdbt_sync_and_channel_estimation</key>
<param><key>id</key><value>isdbt_sync_and_channel_estimation_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>offset_max</key><value>10</value></param>
<param><key>transmission_mode</key><value>2k</value></param>
</block>
<block>
<key>isdbt_time_deinterleaver</key>
<param><key>id</key><value>isdbt_time_deinterleaver_0</value></param>
<param><key>length_A</key><value>0</value></param>
<param><key>segments_A</key><value>1</value></param>
<param><key>length_B</key><value>0</value></param>
<param><key>segments_B</key><value>8</value></param>
<param><key>length_C</key><value>8</value></param>
<param><key>segments_C</key><value>4</value></param>
<param><key>mode</key><value>1</value></param>
</block>
<block>
<key>isdbt_tmcc_decoder</key>
<param><key>id</key><value>isdbt_tmcc_decoder_0</value></param>
<param><key>print_params</key><value>True</value></param>
<param><key>transmission_mode</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>5.8e6/2.0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>0.5e6</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>active_carriers</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>"BER RS "</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>"BER Viterbi "</value></param>
</block>
<connection><source_block_id>blocks_file_source_1_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_1</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>isdbt_sync_and_channel_estimation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_channel_decoding_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_channel_decoding_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_channel_decoding_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_channel_decoding_0_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_channel_decoding_0_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_channel_decoding_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_channel_decoding_0_1</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_channel_decoding_0_1</source_block_id><sink_block_id>blocks_nlog10_ff_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_channel_decoding_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_frequency_deinterleaver_0</source_block_id><sink_block_id>isdbt_time_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_sym_acquisition_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_synchronization_0</source_block_id><sink_block_id>isdbt_tmcc_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_channel_decoding_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_channel_decoding_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_channel_decoding_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_sync_and_channel_estimation_0</source_block_id><sink_block_id>isdbt_tmcc_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_time_deinterleaver_0</source_block_id><sink_block_id>isdbt_symbol_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tmcc_decoder_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tmcc_decoder_0</source_block_id><sink_block_id>isdbt_frequency_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>isdbt_ofdm_sym_acquisition_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>isdbt_ofdm_synchronization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
